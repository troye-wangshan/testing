# Keil uVision project programmer_jtag.uvprojx, settings and files
target Cortex-M0 SDK - Simulator (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: jtag_programmer +hex
  AfterMake: hex2bin  Out_jtag/jtag_programmer.hex
  c flags: Optim=4
  c misc: --c99 --thumb -c
  c include: .\..\..\dk_apps\src\plf\refip\src\driver\i2c_eeprom;.\..\..\dk_apps\src\plf\refip\src\driver\spi;.\..\..\dk_apps\src\plf\refip\src\arch;.\..\..\dk_apps\src\plf\refip\src\arch\compiler\rvds;.\..\..\dk_apps\src\plf\refip\src\arch\ll\rvds;.\..\..\dk_apps\src\plf\refip\src\driver\reg;.\..\..\dk_apps\src\dialog\include;.\include;.\..\..\dk_apps\src\plf\refip\src\driver\gpio;.\..\..\dk_apps\src\plf\refip\src\driver\spi_flash;.\..\..\dk_apps\src\modules\app\api;.\..\..\dk_apps\src\ip\ble\hl\src\rwble_hl;.\..\..\dk_apps\src\ip\ble\ll\src\rwble;.\..\..\dk_apps\src\modules\rwip\api\
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x1b00
  memory RVCT9: RAM 0x81b00 size 0x500
  link misc: --datacompressor off
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group Source Files
    ./src/: peripherals.c crc32.c otpc.c uart.c programmer.c
    ./../../dk_apps/src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.c
    ./../../dk_apps/src/plf/refip/src/driver/spi_flash/: spi_flash.c
    ./../../dk_apps/src/plf/refip/src/driver/spi/: spi.c
    ./../../dk_apps/src/plf/refip/src/driver/gpio/: gpio.c
  group Include Files
    ./include/: peripherals.h periph_setup.h otpc.h uart.h programmer.h
    ./../../dk_apps/src/plf/refip/src/driver/gpio/: gpio.h
    ./../../dk_apps/src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.h
    ./../../dk_apps/src/plf/refip/src/driver/spi/: spi.h
    ./../../dk_apps/src/plf/refip/src/driver/spi_flash/: spi_flash.h
