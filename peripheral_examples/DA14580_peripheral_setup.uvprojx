# Keil uVision project DA14580_peripheral_setup.uvprojx, settings and files
target Cortex-M0 SDK - Simulator (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: periph_setup +hex
  c flags: Optim=1
  c misc: --c99 --thumb -c
  c include: .\..\dk_apps\src\plf\refip\src\driver\syscntl;.\..\dk_apps\src\plf\refip\src\driver\i2c_eeprom;.\..\dk_apps\src\plf\refip\src\driver\spi;.\..\dk_apps\src\plf\refip\src\arch;.\..\dk_apps\src\plf\refip\src\arch\compiler\rvds;.\..\dk_apps\src\plf\refip\src\arch\ll\rvds;.\..\dk_apps\src\plf\refip\src\driver\reg;.\..\dk_apps\src\dialog\include;.\include;.\..\dk_apps\src\plf\refip\src\driver\gpio;.\..\dk_apps\src\plf\refip\src\driver\adc;.\..\dk_apps\src\plf\refip\src\driver\battery;.\..\dk_apps\src\plf\refip\src\driver\spi_flash;.\..\dk_apps\src\modules\app\api;.\..\dk_apps\src\ip\ble\hl\src\rwble_hl;..\dk_apps\src\plf\refip\src\driver\wkupct_quadec;..\dk_apps\src\plf\refip\src\driver\pwm
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x2800
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group Source Files
    ./src/: peripherals.c eeprom_test.c spi_test.c uart.c DA14580_examples.c quad_decoder_test.c pwm_test.c per_ex_hard_fault.c sw_cursor.c
    ../dk_apps/src/plf/refip/src/driver/syscntl/: syscntl.c
    ../dk_apps/src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.c
    ../dk_apps/src/plf/refip/src/driver/spi/: spi.c
    ../dk_apps/src/plf/refip/src/driver/spi_flash/: spi_flash.c
    ../dk_apps/src/plf/refip/src/driver/adc/: adc.c
    ../dk_apps/src/plf/refip/src/driver/gpio/: gpio.c
    ../dk_apps/src/plf/refip/src/driver/battery/: battery.c
    ../dk_apps/src/plf/refip/src/driver/wkupct_quadec/: wkupct_quadec.c
    ../dk_apps/src/plf/refip/src/driver/pwm/: pwm.c
  group Include Files
    ./include/: peripherals.h periph_setup.h eeprom_test.h spi_test.h uart.h DA14580_examples.h sw_cursor.h
    ../dk_apps/src/plf/refip/src/driver/spi/: spi.h
    ../dk_apps/src/plf/refip/src/driver/gpio/: gpio.h
    ../dk_apps/src/plf/refip/src/driver/battery/: battery.h
    ../dk_apps/src/plf/refip/src/driver/spi_flash/: spi_flash.h
    ../dk_apps/src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.h
  group Misc
    ./misc/: serial_out.txt
