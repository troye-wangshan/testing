# Keil uVision project host_proxr.uvprojx, settings and files
target Cortex-M0 SDK - Simulator (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: host_proxr +hex
  c flags: Optim=4
  c misc: --c99 --thumb -c --preinclude da14580_config.h
  c include: .\..\..\..\..\dk_apps\src\dialog\include; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\att; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\att\attm; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\att\atts; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\gap; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\gap\gapc; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\gap\gapc; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\gap\gapm; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\l2c\l2cc; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\smp; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\smp\smpc; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\host\smp\smpm; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\profiles; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\profiles\prox\proxm; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\profiles\prox\proxr; .\..\..\..\..\dk_apps\src\ip\ble\hl\src\rwble_hl; .\..\..\..\..\dk_apps\src\ip\ble\ll\src\controller\llc; .\..\..\..\..\dk_apps\src\ip\ble\ll\src\hcic; .\..\..\..\..\dk_apps\src\ip\ble\ll\src\rwble; .\..\..\..\..\dk_apps\src\modules\common\api; .\..\..\..\..\dk_apps\src\modules\ke\api; .\..\..\..\..\dk_apps\src\modules\rwip\api; .\..\..\..\..\dk_apps\src\plf\refip\src\arch; .\..\..\..\..\dk_apps\src\plf\refip\src\arch\compiler\rvds; .\..\..\..\..\dk_apps\src\plf\refip\src\arch\ll\rvds; .\..\..\..\..\dk_apps\src\plf\refip\src\driver\gpio; .\..\..\..\..\dk_apps\src\plf\refip\src\driver\i2c_eeprom; .\..\..\..\..\dk_apps\src\plf\refip\src\driver\reg; .\..\..\..\..\dk_apps\src\plf\refip\src\driver\spi; .\..\..\..\..\dk_apps\src\plf\refip\src\driver\timer; .\..\..\..\..\dk_apps\src\plf\refip\src\driver\uart; .\include
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x2800
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group Source Files
    ./src/: app_task.c ble_msg.c interrupts.c peripherals.c timer.c queue.c app_button_led.c spi_booter.c app.c spi_hci_msg.c
    ../../../../dk_apps/src/plf/refip/src/driver/spi/: spi.c
    ../../../../dk_apps/src/plf/refip/src/driver/gpio/: gpio.c
  group Include Files
    ./include/: app.h app_button_led.h app_task.h ble_msg.h gap_task.h peripherals.h queue.h spi_booter.h periph_setup.h spi_hci_msg.h prox_reporter_ext.h prox_reporter_ext_581.h
    ./: da14580_config.h
  group Misc
    ./misc/: serial_out.txt
